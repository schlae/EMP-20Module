# Repository schlae/EMP-20Module

File README.md:

# Universal EMP-20 Family Module

The Needham Electronics EMP-20 is an older parallel-port connected device
programmer that can be found fairly inexpensively and supports a wide
range of older devices, so it is particularly useful for retrocomputing.

The EMP-20 requires a set of family modules to rewire the socket for
particular types of target devices. Typically only power, ground, and VPP
signals route through the family module.

Unfortunately many used EMP-20 devices are missing many family modules, making
them much less useful -- until now!

I've designed a universal family module that can be wired up as many different
modules by following the chart further down the page.

## Fabrication

You can download the [fabrication files here](https://github.com/schlae/EMP-20Module/raw/master/fab/EMP-20Module-Rev1.zip).

Please note that this board is NOT the normal 1.6mm thickness. To fit in the
SIMM socket, you will need to fabricate it with a 1.2mm thickness. Some fab
vendors offer this thickness and are relatively affordable -- take a look at
pcbway.com for example.

Dimensions are 20.32mm x 118.11mm. Two layers, 1oz copper finish. You can go
for ENIG if you wish, but the originals were HASL so that's probably fine too.

## Module Wiring Chart

Each module has two sets of wiring, one for the A side and the other for the
B side. For example, if you want to build module 01, you will need to assemble
both rows 01A and 01B from the table below.

To begin wiring a module, orient the board so the text on the right side is
not upside down. First thing to assemble is the ID code. Convert the ID code
from the table into binary. Wherever there is a logical '1', solder across
the appropriate IDx jumpers on the top right of the board. For example, if
you're assembling module 09A, you have module ID 17, which is 10001 in binary.
This means that you will solder jumpers on ID0 and ID4.

Next, go through the list of grounds and solder a short across that pin. For
example, if the number '2' is in the list of grounds, solder a jumper wire
or place a 0 ohm resistor across the two pads labeled '2' on the board.

For the point-to-point wiring, solder a wire from the right-most pad next to
the number called out, then run it to the right-most pad next to the other
number that is called out. For example, 17->72 means you have to solder a
jumper wire from the right-most pad next to the number 17 and run it to
the right-most pad next to the number 72.

Some modules have passive components on them. 14->150pF-\>GND means that you
need to solder a 150pF surface mount capacitor across the pads next to the
number 14. 12->100 ohm->70 means that you need to solder a 100 ohm resistor
to the right-most pad next to number 12, then solder a jumper wire to the
other terminal of the resistor (DO NOT let it touch the left pad) and run
it to the right-most pad next to number 70. It's basically just a jumper
wire with a resistor in series.

In the picture, the family module is partially assembled. Only the A side has
any wiring, and it is set to ID 5. A 150pF capacitor to ground is installed at
pad 14, and a jumper wire goes from pad 16 to pad 72.

When you've finished that side, you may want to check it with a multimeter
to make sure you didn't make any mistakes. Then rotate the board 180 degrees
and repeat the process with side B.

You'll want to test the module first with a device that you don't care about
just in case something's not wired correctly. If you can program and verify
successfully, then congratulations!

| Module ID | Name                   | ID code | Grounds    | Point-to-point                                         |  Special                             
| :-------: | ---------------------- | :-----: | :--------: | ------------------------------------------------------ | -------- 
|       01A | Standard EPROM         | 1 | 2 | 17->72, 19->62, 25->70, 28->58, 29->68, 32->56, 33->66 |
|       01B | 16 bit EPROMS          | 2 | 21, 21 | 3->68, 23->62, 40->58, 45->70 |
|       02A | Intel 8048/49/51/52 uP | 3 | 2, 19 | 11->72, 13->70, 23->68, 28->62, 32->58, 45->54 |
|       02B | 87X7xx                 | 4 | 66 | 2->70, 6->68, 14->72, 18->58, 25->56, 29->54 |
|       03A | PAL 16V8/20V8/22V10    | 5 | 2 | 6->62, 16->72, 18->68, 20->58, 21->56, 22->70, 25->54, | 14->150pF-\>GND
|       03B | GAL 16V8/22V10, etc    | 6 | 2 | 3->62, 5->55, 7->61, 18->72, 21->70, 22->58, 24->56, 25->68, 28->64, 29->66 |
|       04A | PIC16C5x family        | 7 | 45, 64 | 10->72, 11->62, 22->58, 26->56, 33->66 | 12->100 ohm->70, 29->100 ohm->68
|       04B | Serial EEPROMS         | 8 | 16, 19, 66 | 2->70, 3->68, 5->56, 7->72, 9->62, 17->18->54, 21->58 |
|       05A | Zilog Z86              | |
|       05B | Zilog Z86              | |
|       06A | Zilog Z86              | |
|       06B | Zilog Z86              | |
|       07A | Xicor PAL              | |
|       07B | n/a                    | |
|       08A | Cypress EPROMS         | |
|       08B | Large EPROM/flash      | |
|       09A | 68HC705, MACH          | 17 | 2, 46 | 4->72, 19->70, 26->58, 29->62, 36->68, 38->60, 45->56 |
|       09B | 67HC711                | 18 | 41, 64 | 3->44->56, 10->70, 11->62, 13->72, 22->68, 40->58 |
|       10A | EEPROM                 | |
|       10B | n/a                    | |
|       11A | PEEL devices           | 21 | 2 | 3->68, 4->70, 14->72, 18->58, 20->62, 21->56, 24->60, 25->54 |
|       11B | TMS7782                | 22 | 45, 64 | 2->72, 11->68, 15->58, 16->70, 18->62, 28->56, 33->54 |
|       12A | PSD                    | |
|       12B | n/a                    | |
|       13A | Altera EP devices      | |
|       13B | Altera                 | |
|       14A | Atmel 22V10            | 27 | 2 | 4->72, 14->70, 16->58, 24->56, 25->60 | 3-> -\|<- 1N5818 ->68 |
|       14B | ATV2500                | 28 | 21 | 3->56, 5->58, 22->60, 36->72, 37->70 | 2-> -\|<- 1N5818 ->68 |
|       15A | 29F100/200             | |
|       15B | EP1800                 | |
|       16A | GAL26V12               | 31 | 15 | 16->68, 26->58 |
|       16B | PIC16C6x/PIC17Cxx      | 32 | 22, 23 | 25->54, 40->68 |
|       17A | 62Txx                  | |
|       17B | 62T/Exx                | |
|       18A | PEEL/ATTiny/X76        | 35 | 2 | 5->68, 6->70, 8->62, 9->56, 16->72, 24->60, 25->54 |  
|       18B | PIC16Cxx               | 36 | 66 | 13->58, 14->68, 18->23->70, 20->25->72, 28->56, 40->54 | 
|       19A | XC72xx                 | |
|       19B | XC95xx (Xilinx)        | |
|       20A | XC72xx                 | |
|       20B | n/a                    | |
|       21A | n/a                    | |
|       21B | AT17Cxx                | |
|       22A | 29F002                 | 43 | 2 | 13->72, 17->68, 21->62, 31->58, 33->56 |
|       22B | 29F1xx                 | 44 | 20, 21 | 2->72, 23->70, 36->62, 39->68, 40->58, 45->56 |
|       23A | Atmel 150x family      | |
|       23B | ATV2500                | |
|       24A | COP87xx                | |
|       24B | COP87xx                | |
|       25A | AT22V10B               | |
|       25B | P51-XA-G1              | |
|       26A | PIC14000               | |
|       26B | 22V10                  | |
|       27A | 26C512                 | |
|       27B | Z86                    | |
|       28A | PIC12C families        | 55 | 20, 21, 64 | 2->56, 3->68, 8->70, 9->72, 46->62 |
|       28B | P28F002                | 56 | 6, 32 | 18->20->68, 23->62, 25->58 |
|       29A | 29F070-psop44          | |
|       29B | 27SF010                | |

This chart is incomplete. I have ohmed out all the modules I have, but I am
counting on the community to provide the rest. If you have a module that's
not on the list, ohm out the connections! Pins 1, 50, 51, 52, and 53 are
always grounded. You can submit a pull request
or contact me directly.

# License

This work is licensed under a Creative Commons Attribution 4.0 International
License. See [https://creativecommons.org/licenses/by/4.0/](https://creativecommons.org/licenses/by/4.0/).

## KiCad design EMP-20 Module.kicad_pcb

Parts:
H1, H2: MountingHole; MH_125
J1: SIDE A; EDGE_DIMM_80_127
J2: SIDE B; EDGE_DIMM_80_127
JP1, JP75: ID0; JMP1608
JP2, JP76: ID1; JMP1608
JP3, JP77: ID2; JMP1608
JP4, JP78: ID3; JMP1608
JP5, JP79: ID4; JMP1608
JP6, JP80: ID5; JMP1608
JP7, JP81: ID6; JMP1608
JP8, JP82: 72; RESC1608X55_HandSoldering
JP9, JP83: ID7; JMP1608
JP10, JP84: 70; RESC1608X55_HandSoldering
JP11, JP85: 69; RESC1608X55_HandSoldering
JP12, JP86: 68; RESC1608X55_HandSoldering
JP13, JP87: 67; RESC1608X55_HandSoldering
JP14, JP88: 66; RESC1608X55_HandSoldering
JP15, JP89: 65; RESC1608X55_HandSoldering
JP16, JP90: 64; RESC1608X55_HandSoldering
JP17, JP91: 63; RESC1608X55_HandSoldering
JP18, JP92: 62; RESC1608X55_HandSoldering
JP19, JP93: 61; RESC1608X55_HandSoldering
JP20, JP94: 60; RESC1608X55_HandSoldering
JP21, JP95: 59; RESC1608X55_HandSoldering
JP22, JP96: 58; RESC1608X55_HandSoldering
JP23, JP97: 57; RESC1608X55_HandSoldering
JP24, JP98: 56; RESC1608X55_HandSoldering
JP25, JP99: 55; RESC1608X55_HandSoldering
JP26, JP100: 54; RESC1608X55_HandSoldering
JP27, JP101: 49; RESC1608X55_HandSoldering
JP28, JP102: 48; RESC1608X55_HandSoldering
JP29, JP103: 47; RESC1608X55_HandSoldering
JP30, JP104: 46; RESC1608X55_HandSoldering
JP31, JP105: 45; RESC1608X55_HandSoldering
JP32, JP106: 44; RESC1608X55_HandSoldering
JP33, JP107: 43; RESC1608X55_HandSoldering
JP34, JP108: 42; RESC1608X55_HandSoldering
JP35, JP109: 41; RESC1608X55_HandSoldering
JP36, JP110: 40; RESC1608X55_HandSoldering
JP37, JP111: 39; RESC1608X55_HandSoldering
JP38, JP112: 38; RESC1608X55_HandSoldering
JP39, JP113: 37; RESC1608X55_HandSoldering
JP40, JP114: 36; RESC1608X55_HandSoldering
JP41, JP115: 35; RESC1608X55_HandSoldering
JP42, JP116: 34; RESC1608X55_HandSoldering
JP43, JP117: 33; RESC1608X55_HandSoldering
JP44, JP118: 32; RESC1608X55_HandSoldering
JP45, JP119: 31; RESC1608X55_HandSoldering
JP46, JP120: 30; RESC1608X55_HandSoldering
JP47, JP121: 29; RESC1608X55_HandSoldering
JP48, JP122: 28; RESC1608X55_HandSoldering
JP49, JP123: 27; RESC1608X55_HandSoldering
JP50, JP124: 26; RESC1608X55_HandSoldering
JP51, JP125: 25; RESC1608X55_HandSoldering
JP52, JP126: 24; RESC1608X55_HandSoldering
JP53, JP127: 23; RESC1608X55_HandSoldering
JP54, JP128: 22; RESC1608X55_HandSoldering
JP55, JP129: 21; RESC1608X55_HandSoldering
JP56, JP130: 20; RESC1608X55_HandSoldering
JP57, JP131: 19; RESC1608X55_HandSoldering
JP58, JP132: 18; RESC1608X55_HandSoldering
JP59, JP133: 17; RESC1608X55_HandSoldering
JP60, JP134: 16; RESC1608X55_HandSoldering
JP61, JP135: 15; RESC1608X55_HandSoldering
JP62, JP136: 14; RESC1608X55_HandSoldering
JP63, JP137: 13; RESC1608X55_HandSoldering
JP64, JP138: 12; RESC1608X55_HandSoldering
JP65, JP139: 11; RESC1608X55_HandSoldering
JP66, JP140: 10; RESC1608X55_HandSoldering
JP67, JP141: 9; RESC1608X55_HandSoldering
JP68, JP142: 8; RESC1608X55_HandSoldering
JP69, JP143: 7; RESC1608X55_HandSoldering
JP70, JP144: 6; RESC1608X55_HandSoldering
JP71, JP145: 5; RESC1608X55_HandSoldering
JP72, JP146: 4; RESC1608X55_HandSoldering
JP73, JP147: 3; RESC1608X55_HandSoldering
JP74, JP148: 2; RESC1608X55_HandSoldering

Connections:
unnamed: J1.1, J1.50, J1.51, J1.52, J1.53, JP8.2 (B), JP10.2 (B), JP11.2 (B), JP12.2 (B), JP13.2 (B), JP14.2 (B), JP15.2 (B), JP16.2 (B), JP17.2 (B), JP18.2 (B), JP19.2 (B), JP20.2 (B), JP21.2 (B), JP22.2 (B), JP23.2 (B), JP24.2 (B), JP25.2 (B), JP26.2 (B), JP27.2 (B), JP28.2 (B), JP29.2 (B), JP30.2 (B), JP31.2 (B), JP32.2 (B), JP33.2 (B), JP34.2 (B), JP35.2 (B), JP36.2 (B), JP37.2 (B), JP38.2 (B), JP39.2 (B), JP40.2 (B), JP41.2 (B), JP42.2 (B), JP43.2 (B), JP44.2 (B), JP45.2 (B), JP46.2 (B), JP47.2 (B), JP48.2 (B), JP49.2 (B), JP50.2 (B), JP51.2 (B), JP52.2 (B), JP53.2 (B), JP54.2 (B), JP55.2 (B), JP56.2 (B), JP57.2 (B), JP58.2 (B), JP59.2 (B), JP60.2 (B), JP61.2 (B), JP62.2 (B), JP63.2 (B), JP64.2 (B), JP65.2 (B), JP66.2 (B), JP67.2 (B), JP68.2 (B), JP69.2 (B), JP70.2 (B), JP71.2 (B), JP72.2 (B), JP73.2 (B), JP74.2 (B)
unnamed: J1.2, JP74.1 (A)
unnamed: J1.3, JP73.1 (A)
unnamed: J1.4, JP72.1 (A)
unnamed: J1.5, JP71.1 (A)
unnamed: J1.6, JP70.1 (A)
unnamed: J1.7, JP69.1 (A)
unnamed: J1.8, JP68.1 (A)
unnamed: J1.9, JP67.1 (A)
unnamed: J1.10, JP66.1 (A)
unnamed: J1.11, JP65.1 (A)
unnamed: J1.12, JP64.1 (A)
unnamed: J1.13, JP63.1 (A)
unnamed: J1.14, JP62.1 (A)
unnamed: J1.15, JP61.1 (A)
unnamed: J1.16, JP60.1 (A)
unnamed: J1.17, JP59.1 (A)
unnamed: J1.18, JP58.1 (A)
unnamed: J1.19, JP57.1 (A)
unnamed: J1.20, JP56.1 (A)
unnamed: J1.21, JP55.1 (A)
unnamed: J1.22, JP54.1 (A)
unnamed: J1.23, JP53.1 (A)
unnamed: J1.24, JP52.1 (A)
unnamed: J1.25, JP51.1 (A)
unnamed: J1.26, JP50.1 (A)
unnamed: J1.27, JP49.1 (A)
unnamed: J1.28, JP48.1 (A)
unnamed: J1.29, JP47.1 (A)
unnamed: J1.30, JP46.1 (A)
unnamed: J1.31, JP45.1 (A)
unnamed: J1.32, JP44.1 (A)
unnamed: J1.33, JP43.1 (A)
unnamed: J1.34, JP42.1 (A)
unnamed: J1.35, JP41.1 (A)
unnamed: J1.36, JP40.1 (A)
unnamed: J1.37, JP39.1 (A)
unnamed: J1.38, JP38.1 (A)
unnamed: J1.39, JP37.1 (A)
unnamed: J1.40, JP36.1 (A)
unnamed: J1.41, JP35.1 (A)
unnamed: J1.42, JP34.1 (A)
unnamed: J1.43, JP33.1 (A)
unnamed: J1.44, JP32.1 (A)
unnamed: J1.45, JP31.1 (A)
unnamed: J1.46, JP30.1 (A)
unnamed: J1.47, JP29.1 (A)
unnamed: J1.48, JP28.1 (A)
unnamed: J1.49, JP27.1 (A)
unnamed: J1.54, JP26.1 (A)
unnamed: J1.55, JP25.1 (A)
unnamed: J1.56, JP24.1 (A)
unnamed: J1.57, JP23.1 (A)
unnamed: J1.58, JP22.1 (A)
unnamed: J1.59, JP21.1 (A)
unnamed: J1.60, JP20.1 (A)
unnamed: J1.61, JP19.1 (A)
unnamed: J1.62, JP18.1 (A)
unnamed: J1.63, JP17.1 (A)
unnamed: J1.64, JP16.1 (A)
unnamed: J1.65, JP15.1 (A)
unnamed: J1.66, JP14.1 (A)
unnamed: J1.67, JP13.1 (A)
unnamed: J1.68, JP12.1 (A)
unnamed: J1.69, JP11.1 (A)
unnamed: J1.70, JP10.1 (A)
unnamed: J1.71, JP9.1 (A)
unnamed: J1.72, JP8.1 (A)
unnamed: J1.73, JP7.1 (A)
unnamed: J1.74, JP6.1 (A)
unnamed: J1.75, JP5.1 (A)
unnamed: J1.76, JP4.1 (A)
unnamed: J1.77, JP3.1 (A)
unnamed: J1.78, JP2.1 (A)
unnamed: J1.79, JP1.1 (A)
unnamed: J1.80, JP1.2 (B), JP2.2 (B), JP3.2 (B), JP4.2 (B), JP5.2 (B), JP6.2 (B), JP7.2 (B), JP9.2 (B)
unnamed: J2.1, J2.50, J2.51, J2.52, J2.53, JP82.2 (B), JP84.2 (B), JP85.2 (B), JP86.2 (B), JP87.2 (B), JP88.2 (B), JP89.2 (B), JP90.2 (B), JP91.2 (B), JP92.2 (B), JP93.2 (B), JP94.2 (B), JP95.2 (B), JP96.2 (B), JP97.2 (B), JP98.2 (B), JP99.2 (B), JP100.2 (B), JP101.2 (B), JP102.2 (B), JP103.2 (B), JP104.2 (B), JP105.2 (B), JP106.2 (B), JP107.2 (B), JP108.2 (B), JP109.2 (B), JP110.2 (B), JP111.2 (B), JP112.2 (B), JP113.2 (B), JP114.2 (B), JP115.2 (B), JP116.2 (B), JP117.2 (B), JP118.2 (B), JP119.2 (B), JP120.2 (B), JP121.2 (B), JP122.2 (B), JP123.2 (B), JP124.2 (B), JP125.2 (B), JP126.2 (B), JP127.2 (B), JP128.2 (B), JP129.2 (B), JP130.2 (B), JP131.2 (B), JP132.2 (B), JP133.2 (B), JP134.2 (B), JP135.2 (B), JP136.2 (B), JP137.2 (B), JP138.2 (B), JP139.2 (B), JP140.2 (B), JP141.2 (B), JP142.2 (B), JP143.2 (B), JP144.2 (B), JP145.2 (B), JP146.2 (B), JP147.2 (B), JP148.2 (B)
unnamed: J2.2, JP148.1 (A)
unnamed: J2.3, JP147.1 (A)
unnamed: J2.4, JP146.1 (A)
unnamed: J2.5, JP145.1 (A)
unnamed: J2.6, JP144.1 (A)
unnamed: J2.7, JP143.1 (A)
unnamed: J2.8, JP142.1 (A)
unnamed: J2.9, JP141.1 (A)
unnamed: J2.10, JP140.1 (A)
unnamed: J2.11, JP139.1 (A)
unnamed: J2.12, JP138.1 (A)
unnamed: J2.13, JP137.1 (A)
unnamed: J2.14, JP136.1 (A)
unnamed: J2.15, JP135.1 (A)
unnamed: J2.16, JP134.1 (A)
unnamed: J2.17, JP133.1 (A)
unnamed: J2.18, JP132.1 (A)
unnamed: J2.19, JP131.1 (A)
unnamed: J2.20, JP130.1 (A)
unnamed: J2.21, JP129.1 (A)
unnamed: J2.22, JP128.1 (A)
unnamed: J2.23, JP127.1 (A)
unnamed: J2.24, JP126.1 (A)
unnamed: J2.25, JP125.1 (A)
unnamed: J2.26, JP124.1 (A)
unnamed: J2.27, JP123.1 (A)
unnamed: J2.28, JP122.1 (A)
unnamed: J2.29, JP121.1 (A)
unnamed: J2.30, JP120.1 (A)
unnamed: J2.31, JP119.1 (A)
unnamed: J2.32, JP118.1 (A)
unnamed: J2.33, JP117.1 (A)
unnamed: J2.34, JP116.1 (A)
unnamed: J2.35, JP115.1 (A)
unnamed: J2.36, JP114.1 (A)
unnamed: J2.37, JP113.1 (A)
unnamed: J2.38, JP112.1 (A)
unnamed: J2.39, JP111.1 (A)
unnamed: J2.40, JP110.1 (A)
unnamed: J2.41, JP109.1 (A)
unnamed: J2.42, JP108.1 (A)
unnamed: J2.43, JP107.1 (A)
unnamed: J2.44, JP106.1 (A)
unnamed: J2.45, JP105.1 (A)
unnamed: J2.46, JP104.1 (A)
unnamed: J2.47, JP103.1 (A)
unnamed: J2.48, JP102.1 (A)
unnamed: J2.49, JP101.1 (A)
unnamed: J2.54, JP100.1 (A)
unnamed: J2.55, JP99.1 (A)
unnamed: J2.56, JP98.1 (A)
unnamed: J2.57, JP97.1 (A)
unnamed: J2.58, JP96.1 (A)
unnamed: J2.59, JP95.1 (A)
unnamed: J2.60, JP94.1 (A)
unnamed: J2.61, JP93.1 (A)
unnamed: J2.62, JP92.1 (A)
unnamed: J2.63, JP91.1 (A)
unnamed: J2.64, JP90.1 (A)
unnamed: J2.65, JP89.1 (A)
unnamed: J2.66, JP88.1 (A)
unnamed: J2.67, JP87.1 (A)
unnamed: J2.68, JP86.1 (A)
unnamed: J2.69, JP85.1 (A)
unnamed: J2.70, JP84.1 (A)
unnamed: J2.71, JP83.1 (A)
unnamed: J2.72, JP82.1 (A)
unnamed: J2.73, JP81.1 (A)
unnamed: J2.74, JP80.1 (A)
unnamed: J2.75, JP79.1 (A)
unnamed: J2.76, JP78.1 (A)
unnamed: J2.77, JP77.1 (A)
unnamed: J2.78, JP76.1 (A)
unnamed: J2.79, JP75.1 (A)
unnamed: J2.80, JP75.2 (B), JP76.2 (B), JP77.2 (B), JP78.2 (B), JP79.2 (B), JP80.2 (B), JP81.2 (B), JP83.2 (B)

Board: 2 copper layers, 20.3 x 118.1 mm, 152 parts (0 on the bottom side), 152 nets.

## Commit log

2019-08-13 Rev 1 Fab out
2019-08-13 Fix file path
2020-01-22 Add pinout for modules 11 and 14
2022-03-02 Add pinouts for 22A/22B
    # Notes
    * Grounds are 1,50,51,52,53
    * Notch is between 40 and 41
    # 22A
    79, 78, 76, 74 to 80 == 0b101011 == ID 43
    Extra grounds: 2

Notices in the files:
EMP-20 Module.kicad_pcb:
EMP-20 UNIVERSAL FAMILY MODULE © 2019 @TUBETIMEUS
